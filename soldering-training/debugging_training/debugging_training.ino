const int FWD = 10; // pin assigned to forward control
const int REV = 11; // pin assigned to reverse control
const int FWD_LED = 9;
const int REV_LED = 8;

void setup() {
  // Assign FWD and REV pins as outputs
  pinMode(FWD, OUTPUT);
  pinMode(REV, OUTPUT);
  pinMode(FWD_LED, OUTPUT);
  pinMode(REV_LED, OUTPUT);
}

void loop() {
  // Motor will oscillate forward and backward
  digitalWrite(REV, LOW);
  digitalWrite(FWD_LED, HIGH);
  digitalWrite(REV_LED, LOW);
  for (int i = 0; i < 256; i += 1) {
    analogWrite(FWD, i);
    delay(10);
  }
  for (int i = 255; i >= 0; i -= 1) {
    analogWrite(FWD, i);
    delay(10);
  }
  digitalWrite(FWD, LOW);
  digitalWrite(FWD_LED, LOW);
  digitalWrite(REV_LED, HIGH);
  for (int i = 0; i < 256; i += 1) {
    analogWrite(REV, i);
    delay(10);
  }
  for (int i = 255; i >= 0; i -= 1) {
    analogWrite(REV, i);
    delay(10);
  }
}
