const int FWD = 9; // pin assigned to forward control
const int REV = 10; // pin assigned to reverse control

void setup() {
  // Assign FWD and REV pins as outputs
  pinMode(FWD, OUTPUT);
  pinMode(REV, OUTPUT);
}

void loop() {
  // Motor will oscillate forward and backward
  digitalWrite(REV, LOW);
  for (int i = 0; i < 256; i += 1) {
    analogWrite(FWD, i);
    delay(10);
  }
  for (int i = 255; i >= 0; i -= 1) {
    analogWrite(FWD, i);
    delay(10);
  }
  digitalWrite(FWD, LOW);
  for (int i = 0; i < 256; i += 1) {
    analogWrite(REV, i);
    delay(10);
  }
  for (int i = 255; i >= 0; i -= 1) {
    analogWrite(REV, i);
    delay(10);
  }
}
