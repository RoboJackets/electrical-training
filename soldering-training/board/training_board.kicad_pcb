# Repository RoboJackets/electrical-training

File README.md:

# RoboJackets Electrical Training

**Please bookmark this page!**

**Also, be sure to visit the RoboJackets Firmware Training page as well:** https://github.com/RoboJackets/firmware-training

Welcome to the source repository for the 2025 RoboJackets Electrical training program!

## Training Schedule 2025

* Time: 6:30pm - 8:00pm on Mondays and Tuesdays
* Bring: You, Your computer, A separate soul to sacrifice

Here is a breakdown of what electrical training will be about week-to-week:
* Week 1: Introductions and electricity basics and Arduino
* Week 2: Electricity components and Kicad Parts and Libraries
* Week 3: Kicad Schematics
* Week 4: Fall Break (**NO** training this week)
* Week 5: Kicad Board Layout
* Ext. Week 5: Soldering Workshop @ The HIVE Makerspace<sup>*1,2*</sup>
* Week 6: Overflow training<sup>*3*</sup>

Note<sup>*1*</sup>: Ext. Week 5 is on a Friday, and y'all be able to get practice with both surface mount (SMD) and through-hole (THT) soldering.\
Note<sup>*2*</sup>: Check out the Hive's website to learn more about it: https://hive.ece.gatech.edu/about/ \
Note<sup>*3*</sup>: Week 6 <ins>most likely *won't*</ins> be taking place, but we will let y'all know ahead of time. 

## Dates and Locations:
* Week 1:
    * Monday (September 15th): **Skiles 202**
    * Tuesday (September 16th): **Boggs B9**
* Week 2:
    * Monday (September 22nd): **Skiles 254**
    * Tuesday (September 23rd): **Skiles 171**
* Week 3:
    * Monday (September 29th): **Skiles 254**
    * Tuesday (September 30th): **Skiles 171**
* Week 4:
    * **FALL BREAK——STAY *<ins>AWAY</ins>* FROM SCHOOL AT ALL COSTS FOR YOUR OWN SANITY!** 
* Week 5:
    * Monday (October 13th): **Skiles 254**
    * Tuesday (October 14th): **Skiles 171**
* Solder Training:
    * TBD: **The Hive Makerspace: The Interdisciplinary Design Commons (IDC)**
* Week 6 (Overflow):
    * Monday (October 20th): **Skiles 254**
    * Tuesday (October 21st): **Skiles 171**

## KiCad design soldering-training/board/training_board.kicad_pcb

Parts:
C1, C3: 0.1uF 16V; C0805
C2: 1uF 16V; C0805
C4, C5: 0.1 uF; CAPC1608X85
C6: 22 nF; CAPC1608X85
F1: 350 mA; F1812
J1: MAIN_PWR; PJ-037A
LED1, LED3: ORANGE; CHIP-LED0603
LED2, LED4: GREEN; CHIP-LED0603
OUT0: 1X2-3.5MM
Q2: ARDUINOR3-NOIOREF-NOTEXT; ARDUINOR3-NOTEXT-NOIOREF
R1, R3: 1K; R0603
R2, R7: 2.4K; R0603
R6: 10K; R0603
R8: 10k; R0603
S1: EG1903-ND; EG1218
SW1: PTS645
U2: DRV8876PWPRPWP0016J_NV; PWP0016J_NV

Connections:
3V: Q2.3V
+5V: Q2.5V, R6.2, R8.2, U2.5 (VREF), U2.16 (PMODE)
+12V: C1.1, C2.1, F1.1, J1.P$2 (1), Q2.VIN, R2.2
CPH: C6.1, U2.13 (CPH)
CPL: C6.2, U2.14 (CPL)
GND: C1.2, C2.2, C3.2, C4.2, J1.P$1 (2), LED1.C, LED2.C, LED3.C, LED4.C, Q2.GND, Q2.GND1, Q2.GND2, S1.S, SW1.1, SW1.2 (1), U2.6 (IPROPI), U2.7 (IMODE), U2.9 (PGND), U2.15 (GND), U2.17 (PAD)
M1_FWD: Q2.D10, U2.2 (PH_IN2)
M1_REV: Q2.D11, U2.1 (EN_IN1)
unnamed: LED4.A, R7.1
unnamed: Q2.D9, R1.2
unnamed: Q2.D8, R3.2
unnamed: LED1.A, R1.1
unnamed: LED3.A, R3.1
unnamed: LED2.A, R2.1
OUT1: OUT0.2, U2.8 (OUT1)
OUT2: OUT0.1, U2.10 (OUT2)
RESET: C3.1, Q2.RESET (/RESET), R6.1, SW1.3 (2), SW1.4 (2)
VCP: C5.2, U2.12 (VCP)
VM: C4.1, C5.1, F1.2, R7.2, U2.11 (VM)
~SLEEP: R8.1, S1.P, U2.3 (SLEEP_N)

Notes on the sheet:
Device is disabled until nSleep input is pulled high
Decoupling capacitors help ensure a relatively constant output voltage even in the event of current spikes
Cap needs to be rated for VM acc. to datasheet
Two user controlled LEDs are provided in common anode configuration. Sending a logic '1' to these pins will cause the LED to turn on.
The top part of this symbol represents the pin inside the barrel jack (usually positive), while the bottom represents the spring-loaded tab that contacts the outside (usually negative).
Microcontroller code resets when RESET pin is shorted to ground. This is accomplished with a momentary pushbutton. A 10k ohm pull-up resistor ensures the RESET pin is high when the pushbutton is an open circuit.
Barrel Jack and 12V Power Indicator
From Adafruit Library
Datasheet recommends a low ESR, VM rated bypass capacitor between VM and GND. It also recommends a 16V capacitor between VCP and VM
7-12V from the Barrel Jack is fed into the Vin pin on the Arduino Uno so the internal regulator provides 5V to power the logic levels in the circuit.
Motor Driver chips are powered directly from the 12V supply. Speed can be controlled by applying a PWM signal to the M1_FWD or M1_REV pins. The output of the internal H Bridge is applied across OUT1 and OUT2. PMode is configured in this way, but can be configured for other settings. Refer to datash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
From datasheet: "The internal current regulation can be disabled by tying IPROPI to GND and setting the VREF pin voltage greater than GND." Current regulation isn't necessary here, so we can go ahead and disable it.
350mA fuse specced for Sparkfun Gearmotors with .35A no-load current and 1.3A stall current No intended mechanism for this motor so should be fine.
Motor Driver Chips
Arduino Uno Microcontroller

Board: 2 copper layers, 68.6 x 53.4 mm, 25 parts (0 on the bottom side), 19 nets.

Other parts of the board:
U$1: ROBOJACKETS
U$2: ROBOBUZZ_1.0X

## KiCad design labs/week-4.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: GY-521-MPU-6050; 1X08
MOD1: ARDUINO-UNO-R3; ARDUINO_UNO_R3
R1, R3: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R7: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 1.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1: 330; 742C163331JP
SW1, SW2, SW3: PTS645; PTS645SM43SMTR; DIGIKEY CKN9112CT-ND
U1: TLE493DA2B6HTSA1

Connections:
+3.3V: C4.1, MOD1.3V3, R5.2, R6.1, U1.4 (VDD)
AD0: J1.7
D1_CTRL: MOD1.D11, RN1.1
D2_CTRL: MOD1.D10, RN1.3
D3_CTRL: MOD1.D9, RN1.5
D4_CTRL: MOD1.D6, RN1.7
D5_CTRL: MOD1.D5, RN1.9
MPU_INT: J1.8, MOD1.D2
unnamed: D1.2 (A), RN1.2
unnamed: D2.2 (A), RN1.4
unnamed: D3.2 (A), RN1.6
unnamed: D4.2 (A), RN1.8
unnamed: D5.2 (A), RN1.10
unnamed: D6.2 (A), RN1.16
unnamed: R1.1, SW2.3, SW2.4
unnamed: R3.1, SW1.3, SW1.4
SCL: J1.3, MOD1.A5 (A5/SCL)
SDA: J1.4, MOD1.A4 (A4/SDA)
SW1_INT: C1.1, MOD1.D3, R1.2, R7.1
XCL: J1.6, R5.1, U1.1 (SCL/INT)
XDA: J1.5, R6.2, U1.6 (SDA)
~RESET: C3.1, MOD1.RESET (/RESET), R4.2, SW3.3, SW3.4
~SW2_INPUT: C2.1, MOD1.D4, R2.2, R3.2

Notes on the sheet:
Magnetometer Sensor
Shows 5V Power
SW1 is pulled high with a normally open momentary pushbutton. When you push on the button, the digital value will be a 1. When you do not push on the button, the digital value will be a 0. SW1 is also connected to an interrupt pin.
Buttons
Arduino Uno Microcontroller
This is just as an example (will not be populated). NOTE - use of external mag is poorly documented.
GY-521-MPU-6050 has XDA and XCL. These are external I2C bus. This allows for an external magnetometer.
LEDs
A RC circuit is present for all buttons to provide debouncing. Debouncing is so that the function will not be triggered more than once per press due to noise.
6-Axis Sensor
Connects to Pin D3 of Arduino
SCL and SDA - main I2C bus to MCU. XCL and XDA - external I2C bus. This allows for an external magnetometer. AD0 - sets I2C address. (Not Connected) MPU_INT - interrupt for new packet
Five user controlled LEDs are provided in common anode configuration. Sending a logic '1' to these pins will cause the LED to turn on. All pins PWM capable.
Connects to Pin D4 of Arduino
SW2 is pulled low with a normally open momentary pushbutton. When you push on the button, the digital value will be a 0. When you do not push on the button, the digital value will be a 1.
Microcontroller code resets when !RESET pin is shorted to ground. This is accomplished with a momentary pushbutton. A 10k ohm pull-up resistor ensures the !RESET pin is high when the pushbutton is an open circuit.

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
Board: 2 copper layers, 24 parts (0 on the bottom side), 24 nets, no tracks yet.

## Commit log (part)

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2016-08-19 Initial commit from past repository
2016-08-19 New voltage regulator, route board, condense libraries
2016-08-19 Fix routing error
2016-08-21 Switched RGB LED driver ICs, added button, NEEDS ROUTING
2016-08-21 made button inputs have RC circuit to debounce
2016-08-22 removed junk
2016-08-23 Fixed via overlap
2016-08-25 PCB fixes for overlaps
2016-08-25 Resize board to 30x30 then reroute
2016-08-25 Clean up routing, fix silkscreen labels
2016-08-26 Added pullup on reset pin
2016-08-26 Minor PCB changes, change resistor sizes
2016-08-26 Minor pcb routing changes
2016-08-26 Fix library files
2016-08-31 Adding Ignore List
2016-08-31 Eliminated Redundant Pull-Up Resistor
    The 10k on the +5V of the switch was redundant with the 39k series
    resistor already being present
    The 10k resistor has been removed
    The 39k was not value critical, so the value has been changed to 10k to
    reduce part count
2016-08-31 Removed the Series Resistor Instead
    Pull-Up was OK
    The 0.1uF capacitor should be sufficient to remove switch bounce
    All silkscreen has been moved to the top layer
2016-08-31 Optimized a Few Traces
2016-08-31 Silkscreen Optimization
2016-09-15 added markdown for upload to Attiny84
2016-09-16 Fixed RGB LED Footprint
2016-09-16 Got rid of a sharp corner
2016-09-16 Training board minor fixes for RGB led
2016-09-19 slides week 1
2016-09-27 added wk 2 slides
2016-10-03 files test commit
2016-10-03 This is a summary of my changes
    I dropped in a link to some sick beatz
2016-10-03 Revert "This is a summary of my changes"
    This reverts commit 2fc592a0f47edc7c51dc1ec486dabc59e25e973f.
2016-10-03 Added sweet new lines
    Its all about the interrupts
2016-10-04 Wk 3 slides
2016-10-17 Add Project Resources
2016-10-18 ya know, just working on the next big rap song
2016-10-20 Added scripts for training
2016-10-21 Updated script readme
2016-10-21 added wk 4 slides
2016-10-21 cheaters
2016-10-26 Pushing robocup edits
2016-10-31 Completed slides 5
2016-10-31 Slides 5 overview fix
2016-11-07 updated avrdude.conf
2016-11-07 attiny example
2016-11-16 added slides!
2017-07-31 First Version Completed
    Added extra custom parts to the library, completed the schematics
2017-08-01 Separate clocks for registers
2017-08-04 Minor Changes based on Manipulation w/ LCD
2017-08-13 Haptic Drive Update
2017-08-13 Board File Initial Commit
    Library Updated. 328p pin configuration reassigned
2017-08-16 added three buttons
2017-08-16 add image
2017-08-16 begin 3 button board
2017-08-23 3 Button Board completed
    LCD flipped, slight changes in shifter, Buzzer and SPI location
2017-08-24 Minor Updates
    Board rearranged to fit in MINI USB port. MINI USB port used as plenty
    of supply exists in the shop
2017-09-02 Board Updated according to Design Review
2017-09-07 Board Revision
    Reference Designator updated, wonky silkscreen fixed, Library updated
    and 2x3 header replaced with shrouded version
2017-09-08 Keep updating
    Changed to Class5, schematics alignment corrected.
2017-09-08 Some final glitches
2017-10-03 training board ver 1.5
2017-10-08 2nd Version
    Indicator LED added, ATMega328p package updated, schematics updated.
2017-10-08 LCD Column pin grounded
2017-10-11 Training Board Updated
    A list of changes:
    1. LCD COM pin: Now connected to Arduino Pin 13
    2. ^that also means the trimmer resistor is removed
    3. LED added, connected to Arduino Pin 12, can be the first thing for trainees to play with
    4. LCD_Reset connected to A3
    5. One of the three buttons is now a RESETN Button
2017-10-13 training board v1.1
2017-10-13 Button Connected
2017-10-28 added first draft of electrical programming slides
2017-10-29 made changes request in PR
2017-10-31 added button, led, and pwm examples
2017-11-01 a tad of cleanup and gitignore update
2017-11-02 a few lib updates
2017-11-02 some fixes to lcd lib
2017-11-02 a tad of cleanup
2017-11-02 small header update
2017-11-02 continuing with small fixes
2017-11-02 it works
2017-11-02 a bit of repo cleanup
2017-11-02 started tutorial
2017-11-02 finishied setup tutorial
2017-11-02 finishied setup tutorial, small patch
2017-11-02 added blinky tutorial
2017-11-02 progress
2017-11-02 finished PWM part
2017-11-02 minor fix
2017-11-02 added challenge
2017-11-06 fixed image references
2017-11-13 Markdown test
2017-11-13 Minor Change for testing purposes
2017-11-13 Saving Progress
2017-11-13 Keep updating stuff
2017-11-13 That's how you break a line?
2017-11-13 Almost done
2017-11-13 Mid night review
2017-11-13 Reviewed md
2018-07-21 Started schematic for training board based on atmega328p
2018-07-29 <Relevant Commit Message>
2018-08-03 Completed Schematic
2018-08-05 Routed Electrical Training board
2018-08-09 Routed with larger trace widths and corrected pinouts
2018-08-09 Replaced Thru-Hole with SMD Button
2018-08-10 Moved components around to match structure of Huzzah/Trainii
2018-08-13 Cleaned up the repo
2018-08-17 Moved some labels
2018-08-19 Added eagle training
2018-08-20 Switched positions of things
2018-08-21 Eagle Guide edited, adapted to Eagle 9 ver, added example of good vs bad routing
2018-08-21 Migrate all worksheets to LaTeX
2018-08-26 Added filtering caps and re-spec of LDO
2018-08-28 Add datasheets for eagle session
2018-09-01 Week 3 Worksheet ver 0.1
2018-09-06 Added Aesthetics and extra smoothing capacitors
2018-09-11 Additional updates to week 0 sheets
2018-09-12 Finalized the answer sheet
2018-09-12 Restructured Directory
2018-09-12 Added zip of week 0 worksheet
2018-09-23 Cleaned up name
2018-09-23 Cleaned up week 0 content
2018-09-23 Added Pdf to eagle guide
2018-09-23 Corrected the datasheets
2018-09-24 Added a zip of the week 0 pdfs
2018-09-29 Added week 2 training materials to master
2018-09-29 Added Week 1 slides
2018-09-30 Board Changes
    Made the name space bigger, remove thermal traces, rev board, round corner, move to origin
2018-09-30 Additional proof-reading for Week 3
2018-10-01 edited graphics and finished lab guide in LaTeX
2018-10-02 Fixed issue shorting power and ground on stop method lab 1
2018-10-03 Edited Pinouts
2018-10-03 Updated packages of LDO and improved usability
2018-10-03 Small DRC corrections and new gerbers
2018-10-07 Added week 2 slides
2018-10-11 Adds bootloader section to week 3 worksheet
2018-10-11 Deleting extra folders
2018-10-11 Fix minor error
2018-10-11 Created limited library as starting point for eagle CAD
2018-10-18 Readme file deleted
2018-10-22 Added Week 3 slides
2018-10-22 Added Fritzing files for week 3 worksheet example circuit
2018-10-29 Added week 4 slides
2018-11-12 Added week 6 slides
2019-08-01 Cleared out old training board
2019-08-02 Changed folder structure
2019-08-07 Added eagle-libraries as submodule and created blank files for schematic and board
2019-08-12 Preliminary Schematic completed. Components arranged and not routed on board.
2019-09-17 Added Week 0 content to references folder
2019-09-21 Updated Routing, added decoupling capacitors, and added silkscreen
2019-09-22 Added week0 contents and updated README
2019-09-23 Added Week 0 and 1 slides
2019-09-24 Added lab 1 document in references folder
2019-09-28 Removed duplicate and added most important change
2019-10-01 Added Week 2 lab document
2019-10-01 Updated Lab 1 Doc
2019-10-07 Added Week 3 Lab and Presentation
2019-10-09 Edited Lab 3 to reflect usage of buttons instead of switches
2019-10-20 eagle cheat sheet
2019-10-23 edited Week 4 slides after Tuesday
2019-10-27 Fixed Stylistic issues and parts associations
2019-11-12 Added manufacturing files and Component list
2019-11-13 Fixed typo in BOM
2019-11-19 Added datasheet for motor driver chip
2019-11-19 Added Lab 8 Document
2020-01-08 Added Week 5 Slides
2020-03-30 Added Tex Files for eagle cheat sheet
2020-04-01 Changed pdf to reflect tex changes
2020-04-01 Renamed eagle cheat sheet files, edited gitignore to ignore LaTeX intermediate files, and removed extraneous copy of eagle cheat sheet
2020-05-09 Removed 1 motor driver chip from training board
2020-05-09 Fixed reset issue and adjusted traces:
2020-05-10 Finished 1.3 rev silkscreen and layer fixes
2020-05-10 Updated to reference head on eagle libraries
2020-05-10 Removed eagle libraries submodule
2020-05-19 integrated DRV8871 into schematic and board
2020-05-20 Library updates, slight routing changes
2020-05-20 Adjusted board to fix silkscreen overlapping pads
2020-05-28 Fixed extra via and wire stub
2020-06-06 First draft of training board schematic, re-organized for two training board
2020-06-06 First draft of board
2020-06-06 Board aesthetic changes
2020-06-14 Fixed Resistor array part and changed orientation of LEDs.
2020-06-29 Create LICENSE
2020-06-29 Update LICENSE
2020-07-05 Removed unnecessary resistors, cleaned up routing
2020-07-05 Fixed angled routing
2020-07-06 added folder structure for electrical training labs
2020-07-07 Added week3 lab schematic
2020-07-07 Updated week3 lab schematic
2020-07-12 Deleted .BRD file
2020-07-17 Finished schematic, started board
2020-07-18 initial lbr commit
2020-07-19 First finished version
2020-07-19 Added curves to firmware board
2020-07-23 Moved parts to top
2020-07-23 Cleaned up silk screen
2020-07-28 Changed tag size, edited descriptions in schematic
2020-07-28 Fixed minor schematic notes, board silkscreen, and trace widths
2020-08-03 fixed right angle trace
2020-08-04 Moved 2 vias to avoid DRC
2020-08-04 Fixed silkscreen alignment
2020-09-17 week 0 content
2020-09-20 week 1 content
2020-09-27 week 2 content
2020-10-04 week 3 content
2020-10-04 added dues slide
2020-10-04 Added miscellaneous section with eagle tips to eagle cheat sheet
2020-10-04 Added author names and changed date
2020-10-08 removed button function step
2020-10-11 slides and template
2020-10-11 lab 4
2020-10-19 Clean up and week 5
2020-11-19 last minute board fixes
2020-11-19 Fixed wrong layer text
2020-11-19 Renamed SW2 to SW1
2020-11-19 Fixed minor issues and made roboBuzz bigger
2020-11-19 Fixed version
2021-09-20 Updated for 2021-2022 training
    Deleted all presentation and lab files from 2020-2021 training and added Week 0 slides for 2021-2022 training.
2021-09-27 Update README
    Changed 2020-2021
2021-09-28 Updated Lab 1
2021-10-03 Added Week 2 content
2021-10-04 Create Week2
2021-10-04 Updated links
2021-10-14 Adjusted
2021-10-18 Added Week 3 Material
2021-10-18 Added Week3 Schematic
2021-10-25 Added week 4 material
2021-11-15 Added lab and presentation for soldering/debugging training
2021-11-15 Fixed stuff
2021-11-17 Added firmware with error, edited slides
2022-08-28 Changed DRV8871 for DRV8876
2022-08-29 Added BOM
2022-08-29 Updated BOM
2022-08-30 Silkscreen edits
2022-09-16 Update slides for 2022-2023
    fun times
2023-09-18 Update year in presentation title and update week 0 slides
2023-09-18 Update README.md to 2022 for last year's training
2023-09-21 Upload final version of Week 0 presentation and delete outdated slides for later weeks
2023-09-21 Modify README to include more information about this repository and electrical training overall
2023-09-21 Update Kahoot QR code
2023-09-23 added new install instructions
2023-09-25 added new lab
2023-09-25 fixed typos
2023-09-28 Add Week 1 slides
2023-09-29 Reorganize LaTeX files
2023-09-29 Update electrical components and circuits reference with Varun's old edits
2023-10-02 Add Week 2 Lab and rename Week 1 Lab
2023-10-05 Add week 2 slides
2023-10-11 Add schematic for week 3 lab
2023-10-11 Add KiCad symbol library
2023-10-11 Update week 3 lab and add library for challenge
2023-10-12 Finalize changes for week 3 and add latex for week 2 and week 3
2023-10-16 Add lab files for Week 4
2023-10-16 Add KiCAD libraries for week 4
2023-10-17 Add LaTeX for week 4 lab
2023-10-17 Update week 4 lab to include explanation of pcb layers in KiCAD
2023-10-18 Quick fix for broken symbol library
2023-10-18 Fix schematic with fixed symbol
2023-10-25 Convert soldering training board from EAGLE to KiCad
2024-08-13 ommit message for your changes. Lines starting
2024-08-13 sleepy
2024-08-13 chimu tomodachi
2024-08-14 adding cheat files
2024-08-23 added labs 2,3,4
2024-09-02 updated week 0 meeting times
2024-09-03 proofread presentations and labs
