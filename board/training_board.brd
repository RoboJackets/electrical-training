# Repository RoboJackets/electrical-training

File README.md:

# RoboJackets Electrical Training

**Please bookmark this page!**

**Also, be sure to visit the RoboJackets Firmware Training page as well:** https://github.com/RoboJackets/firmware-training

Welcome to the source repository for the 2025 RoboJackets Electrical training program!

## Training Schedule 2025

* Time: 6:30pm - 8:00pm on Mondays and Tuesdays
* Bring: You, Your computer, A separate soul to sacrifice

Here is a breakdown of what electrical training will be about week-to-week:
* Week 1: Introductions and electricity basics and Arduino
* Week 2: Electricity components and Kicad Parts and Libraries
* Week 3: Kicad Schematics
* Week 4: Fall Break (**NO** training this week)
* Week 5: Kicad Board Layout
* Ext. Week 5: Soldering Workshop @ The HIVE Makerspace<sup>*1,2*</sup>
* Week 6: Overflow training<sup>*3*</sup>

Note<sup>*1*</sup>: Ext. Week 5 is on a Friday, and y'all be able to get practice with both surface mount (SMD) and through-hole (THT) soldering.\
Note<sup>*2*</sup>: Check out the Hive's website to learn more about it: https://hive.ece.gatech.edu/about/ \
Note<sup>*3*</sup>: Week 6 <ins>most likely *won't*</ins> be taking place, but we will let y'all know ahead of time. 

## Dates and Locations:
* Week 1:
    * Monday (September 15th): **Skiles 202**
    * Tuesday (September 16th): **Boggs B9**
* Week 2:
    * Monday (September 22nd): **Skiles 254**
    * Tuesday (September 23rd): **Skiles 171**
* Week 3:
    * Monday (September 29th): **Skiles 254**
    * Tuesday (September 30th): **Skiles 171**
* Week 4:
    * **FALL BREAK——STAY *<ins>AWAY</ins>* FROM SCHOOL AT ALL COSTS FOR YOUR OWN SANITY!** 
* Week 5:
    * Monday (October 13th): **Skiles 254**
    * Tuesday (October 14th): **Skiles 171**
* Solder Training:
    * TBD: **The Hive Makerspace: The Interdisciplinary Design Commons (IDC)**
* Week 6 (Overflow):
    * Monday (October 20th): **Skiles 254**
    * Tuesday (October 21st): **Skiles 171**

## EAGLE design board/training_board.brd

Board: 2 copper layers, 68.6 x 53.4 mm, 25 parts (0 on the bottom side), 19 nets.

Parts:
C1, C3: 0.1uF 16V; C0805
C2: 1uF 16V; C0805
C4, C5: 0.1 uF; CAPC1608X85
C6: 22 nF; CAPC1608X85
F1: 350 mA; F1812
J1: MAIN_PWR; PJ-037A
LED1, LED3: ORANGE; CHIP-LED0603
LED2, LED4: GREEN; CHIP-LED0603
OUT: 1X2-3.5MM
Q2: ARDUINOR3-NOIOREF-NOTEXT; ARDUINOR3-NOTEXT-NOIOREF
R1, R3: 1K; R0603
R2, R7: 2.4K; R0603
R6: 10K; R0603
R8: 10k; R0603
S1: EG1903-ND; EG1218
SW1: PTS645
U2: DRV8876PWPRPWP0016J_NV; PWP0016J_NV
U$1: ROBOJACKETS
U$2: ROBOBUZZ_1.0X

Connections:
!SLEEP!: R8.1, S1.P, U2.3
+5V: Q2.5V, R6.2, R8.2, U2.5, U2.16
+12V: C1.1, C2.1, F1.1, J1.P$2, Q2.VIN, R2.2
CPH: C6.1, U2.13
CPL: C6.2, U2.14
GND: C1.2, C2.2, C3.2, C4.2, J1.P$1, LED1.C, LED2.C, LED3.C, LED4.C, Q2.GND, Q2.GND1, Q2.GND2, S1.S, SW1.1, SW1.2, U2.6, U2.7, U2.9, U2.15, U2.17
M1_FWD: Q2.D10, U2.2
M1_REV: Q2.D11, U2.1
unnamed: LED4.A, R7.1
unnamed: Q2.D9, R1.2
unnamed: Q2.D8, R3.2
unnamed: LED1.A, R1.1
unnamed: LED3.A, R3.1
unnamed: LED2.A, R2.1
OUT1: OUT.2, U2.8
OUT2: OUT.1, U2.10
RESET: C3.1, Q2.RESET, R6.1, SW1.3, SW1.4
VCP: C5.2, U2.12
VM: C4.1, C5.1, F1.2, R7.2, U2.11

## EAGLE design board/soldering_training/training_board.brd

Parts:
C1, C3: 0.1uF 16V; C0805
C2: 1uF 16V; C0805
F1: 350 mA; F1812
J1: MAIN_PWR; PJ-037A
LED1, LED3: ORANGE; CHIP-LED0603
LED2, LED4: GREEN; CHIP-LED0603
OUT: 1X2-3.5MM
Q1: DMN2056U; SOT-23-3
Q2: ARDUINOR3-NOIOREF-NOTEXT; ARDUINOR3-NOTEXT-NOIOREF
R1, R3: 1K; R0603
R2, R7: 2.4K; R0603
R4, R6: 10K; R0603
R5: 120K; R0603
S1: EG1903-ND; EG1218
SW1: PTS645
U1: DRV8871HSOP-8; HSOP-8

Connections:
3V: Q2.3V
+5V: Q2.5V, R6.2
+12V: C1.1, C2.1, F1.1, J1.P$2 (1), Q2.VIN, R2.2, S1.P
GND: C1.2, C2.2, C3.2, J1.P$1 (2), LED1.C, LED2.C, LED3.C, LED4.C, Q1.2 (S), Q2.GND, Q2.GND1, Q2.GND2, R4.2, R5.2, SW1.1, SW1.2 (1), U1.1 (GND), U1.9 (GND)
M1_FWD: Q2.D10, U1.2 (IN2)
M1_REV: Q2.D11, U1.3 (IN1)
unnamed: F1.2, R7.2, U1.5 (VM)
unnamed: OUT.2, U1.6 (OUT1)
unnamed: Q1.3 (D), U1.7 (PGND)
unnamed: OUT.1, U1.8 (OUT2)
unnamed: Q1.1 (G), R4.1, S1.S
unnamed: R5.1, U1.4 (ILIM)
unnamed: LED4.A, R7.1
unnamed: Q2.D9, R1.2
unnamed: Q2.D8, R3.2
unnamed: LED1.A, R1.1
unnamed: LED3.A, R3.1
unnamed: LED2.A, R2.1
RESET: C3.1, Q2.RESET (/RESET), R6.1, SW1.3 (2), SW1.4 (2)

Notes on the sheet:
From Adafruit Library
Barrel Jack and 12V Power Indicator
Arduino Uno Microcontroller
Motor Driver Chips
Microcontroller code resets when RESET pin is shorted to ground. This is accomplished with a momentary pushbutton. A 10k ohm pull-up resistor ensures the RESET pin is high when the pushbutton is an open circuit.
7-12V from the Barrel Jack is fed into the Vin pin on the Arduino Uno so the internal regulator provides 5V to power the logic levels in the circuit.
Two user controlled LEDs are provided in common anode configuration. Sending a logic '1' to these pins will cause the LED to turn on.
Motor Driver chips are powered directly from the 12V supply. Speed can be controlled by applying a PWM signal to the M1_FWD or M1_REV pins. The output of the internal H Bridge is applied across OUT1 and OUT2.
350mA fuse specced for Sparkfun Gearmotors with .35A no-load current and 1.3A stall current No intended mechanism for this motor so should be fine.
The top part of this symbol represents the pin inside the barrel jack (usually positive), while the bottom represents the spring-loaded tab that contacts the outside (usually negative).
Decoupling capacitors help ensure a relatively constant output voltage even in the event of current spikes
Switch controls the gate of an N-MOSFET in a low-side switch configuration. When the switch is On and the gate is connected to 12V, the transistor conducts electricity and allows the motor driver chip to turn on. When the switch is off, the pulldown resistor discharges the transistor's gate and shu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
Based on the formula on pg 9 of the datasheet, this limits current to 0.53A before enabling the internal current limit

Board: 2 copper layers, 68.6 x 53.4 mm, 24 parts (0 on the bottom side), 18 nets.

Other parts of the board:
U$1: ROBOJACKETS
U$2: ROBOBUZZ_1.0X

## EAGLE design board/firmware_training/firmware_training_board.brd

Board: 2 copper layers, 54.0 x 45.0 mm, 16 parts (1 on the bottom side), 16 nets.

Parts:
A1: NANO
C1, C2: 0.1uF; C0805
D1, D2, D3, D4, D5: RED; LED5MM
J1: GY-521-MPU-6050; 1X08
R1, R2: 10K; R0603
RN1: 330; RA-8_2506
SW1, SW2: PTS645
U$3: ROBOJACKETS
U$4: ROBOBUZZ_0.8X

Connections:
!SW2_INPUT: A1.D3, C2.1, R2.1, SW2.3, SW2.4
+5V: A1.5V, J1.1, R2.2, SW1.1, SW1.2
D1_CTRL: A1.D11, RN1.1
D1_LED: D1.A, RN1.16
D2_CTRL: A1.D10, RN1.2
D2_LED: D2.A, RN1.15
D3_CTRL: A1.D9, RN1.3
D3_LED: D3.A, RN1.14
D4_CTRL: A1.D6, RN1.4
D4_LED: D4.A, RN1.13
D5_CTRL: A1.D5, RN1.5
D5_LED: D5.A, RN1.12
GND: A1.GND, A1.GND1, C1.2, C2.2, D1.K, D2.K, D3.K, D4.K, D5.K, J1.2, R1.2, SW2.1, SW2.2
SCL: A1.A5, J1.3
SDA: A1.A4, J1.4
SW1_INPUT: A1.D2, C1.1, R1.1, SW1.3, SW1.4

## EAGLE design board/Training_Board.brd

Parts:
C1, C6: 100 nF; C0603
C2: 10uF; C0603
C3, C5: 22 pF; C0603
C4: 100nF; C0603
C7: 10 nF; C0603
C8: 1uF; C0603
D1: RED; CHIP-LED0603
D2: GREEN; CHIP-LED0603
IC1: ATMEGA328-20P; DIL28-3
JP1: PINHD-1X12; 1X12
JP2: PINHD-1X16; 1X16
PRGRM-HEADER: MA03-2
R1: 10k Ohm; R0603
R2, R3: 1k Ohm; R0603
U3: LD1117ASOT223; SOT230P700X180-4
U$2: PTS645PTS645_SMD1; PTS645_SMD
U$4: JST-PH2; JST-PH
XO1: CRYSTALS-NOGND-HC49/4H; HC49

Connections:
+3V3: C1.1, C2.1, IC1.7 (VCC), IC1.20 (AVCC), JP2.2, PRGRM-HEADER.5, R1.1, U3.1 (VOUT), U3.4 (VOUT)
ECHO_3V3: IC1.13 ((PCI23/AIN1)PD7), JP2.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, D1.C, D2.C, IC1.8 (GND), IC1.22 (AGND), JP2.4, PRGRM-HEADER.1, U3.2 (GND), U$2.P$1 (1), U$2.P$2 (1), U$4.1
LED_1: IC1.3 ((PCI17/TXD)PD1), R2.1
LED_2: IC1.6 ((PCI20/XCK/T0)PD4), R3.1
LEFT_A: IC1.14 ((PCI0/ICP/CLKO)PB0), JP2.6
LEFT_B: IC1.15 ((PCI1/OC1A/OC1S)PB1), JP1.7
LIFT_A: IC1.16 ((PCI2/SS/OC1B)PB2), JP1.4
LIFT_B: IC1.11 ((PCI21/T1/OC0B)PD5), JP1.3
LINE_OUT_1: IC1.24 ((PCI9/ADC1)PC1), JP2.7
LINE_OUT_2: IC1.23 ((PCI8/ADC0)PC0), JP2.8
MISO: IC1.18 ((PCI4/MISO)PB4), PRGRM-HEADER.6
MOSI: IC1.17 ((PCI3/MOSI/OC2A)PB3), PRGRM-HEADER.3
MOTOR_FAULT: IC1.2 ((PCI16/RXD)PD0), JP2.16
unnamed: C3.1, IC1.9 (PB6(XTAL1/TOSC1/PCI6)), XO1.2
unnamed: D2.A, R3.2
unnamed: D1.A, R2.2
unnamed: C5.1, IC1.10 (PB7(XTAL2/TOSC2/PCI7)), XO1.1
unnamed: C6.2, IC1.21 (AREF)
RIGHT_A: IC1.26 ((PCI11/ADC3)PC3), JP1.6
RIGHT_B: IC1.25 ((PCI10/ADC2)PC2), JP1.5
RST: IC1.1 (PC6(/RESET/PCI14)), PRGRM-HEADER.2, R1.2, U$2.P$3 (2), U$2.P$4 (2)
SCK: IC1.19 ((PCI5/SCK)PB5), PRGRM-HEADER.4
SCL: IC1.28 ((PCI13/ADC5/SCL)PC5), JP1.2
SDA: IC1.27 ((PCI12/ADC4/SDA)PC4), JP1.1
TICK_LEFT: IC1.4 ((PCI18/INT0)PD2), JP2.9
TICK_RIGHT: IC1.5 ((PCI19/INT1/OC2B)PD3), JP2.10
TRIG_3V3: IC1.12 ((PCI22/AIN0OC0A)PD6), JP2.12
VBAT: C4.1, C7.2, C8.1, JP1.12, U3.3 (VIN), U$4.2

Board: 2 copper layers, 59.0 x 32.0 mm, 22 parts (7 on the bottom side), 29 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.4X

## EAGLE design 2017-2018/lec-buzzer_alt.brd

Parts:
C1: 1.0uF; C0603
C2, C3: 0.1uF; C0603
C4, C5, C6: 1uF; C0603
C7: 10uF; C0603
D1: Blue; LED-0603
D2: Green; LED-0603
LCD1: LCD-S401C39TR; S401C39TR
LS1: PS1240P02BT
R1, R5: 150; R0603
R2, R3, R4: 10k; R0603
S1, S2, S3: SKQGADE010; SW4-SMD-5.2X5.2X1.5MM
U1, U2, U5, U6: 74HC595PW; SOT403-1
U3: DRV2605LDGSR; DGS10
U4: ATMEGA328P-AUR
X1: 2X3SHROUDED
X2: MINI-USB-32005-201; 32005-201

Connections:
1A: LCD1.35 (1A), U1.15 (Q0)
1B: LCD1.34 (1B), U1.1 (Q1)
1C: LCD1.7 (1C), U1.2 (Q2)
1D: LCD1.6 (1D), U1.3 (Q3)
1E: LCD1.5 (1E), U1.4 (Q4)
1F: LCD1.36 (1F), U1.5 (Q5)
1G: LCD1.37 (1G), U1.6 (Q6)
2A: LCD1.30 (2A), U2.15 (Q0)
2B: LCD1.29 (2B), U2.1 (Q1)
2C: LCD1.11 (2C), U2.2 (Q2)
2D: LCD1.10 (2D), U2.3 (Q3)
2E: LCD1.9 (2E), U2.4 (Q4)
2F: LCD1.31 (2F), U2.5 (Q5)
2G: LCD1.32 (2G), U2.6 (Q6)
3A: LCD1.25 (3A), U5.15 (Q0)
3B: LCD1.24 (3B), U5.1 (Q1)
3C: LCD1.15 (3C), U5.2 (Q2)
3D: LCD1.14 (3D), U5.3 (Q3)
3E: LCD1.13 (3E), U5.4 (Q4)
3F: LCD1.26 (3F), U5.5 (Q5)
3G: LCD1.27 (3G), U5.6 (Q6)
4A: LCD1.21 (4A), U6.15 (Q0)
4B: LCD1.20 (4B), U6.1 (Q1)
4C: LCD1.19 (4C), U6.2 (Q2)
4D: LCD1.18 (4D), U6.3 (Q3)
4E: LCD1.17 (4E), U6.4 (Q4)
4F: LCD1.22 (4F), U6.5 (Q5)
4G: LCD1.23 (4G), U6.6 (Q6)
!BTN2: C5.1, R4.1, S2.4 (B0), U4.23 (PC0_(ADC0/PCINT8))
!BTN3: C4.1, R3.1, S1.4 (B0), U4.24 (PC1_(ADC1/PCINT9))
!RESET: C6.1, R2.1, S3.1 (A0), U4.29 (PC6_(RESET/PCINT14)), X1.!RESET (5)
+5V: C2.1, C3.1, C7.1, D2.A, R2.2, S1.1 (A0), S2.1 (A0), U1.16 (VCC), U2.16 (VCC), U3.5 (EN), U3.10 (VDD), U4.4 (VCC_2), U4.6 (VCC), U4.18 (AVCC), U5.16 (VCC), U6.16 (VCC), X1.+5V (2), X2.1
COL: LCD1.28 (COL), U1.7 (Q7)
COM: LCD1.1 (COM1), LCD1.40 (COM2), U4.25 (PC2_(ADC2/PCINT10))
DP1: LCD1.8 (DP1), U2.7 (Q7)
DP2: LCD1.12 (DP2), U5.7 (Q7)
DP3: LCD1.16 (DP3), U6.7 (Q7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R1.1, R3.2, R4.2, R5.1, S3.4 (B0), U1.8 (GND), U2.8 (GND), U3.4 (IN/TRIG), U3.8 (GND), U4.3 (GND_2), U4.5 (GND_3), U4.21 (GND), U5.8 (GND), U6.8 (GND), X1.GND (6), X2.5
LED1: D1.A, U4.14 ((PCINT2/SS/OC1B)_PB2)
LRA/ERM+: LS1.1 (A), U3.7 (OUT+)
LRA/ERM-: LS1.2 (B), U3.9 (OUT-)
MISO: U4.16 ((PCINT4/MISO)_PB4), X1.MISO (1)
MOSI: U4.15 ((PCINT3/OC2A/MOSI)_PB3), X1.MOSI (4)
unnamed: D1.C, R1.2
unnamed: D2.C, R5.2
unnamed: C1.1, U3.1 (REG)
SCK: U4.17 (PB5_(SCK/PCINT5)), X1.SCK (3)
SCL: U3.2 (SCL), U4.28 (PC5_(ADC5/SCL/PCINT13))
SDA: U3.3 (SDA), U4.27 (PC4_(ADC4/SDA/PCINT12))
SFT1-IN: U1.14 (DS), U4.13 ((PCINT1/OC1A)_PB1)
SFT2-IN: U1.9 (Q7S), U2.14 (DS)
SFT3-IN: U2.9 (Q7S), U5.14 (DS)
SFT4-IN: U5.9 (Q7S), U6.14 (DS)
SFT-!OE: U1.13 (!OE), U2.13 (!OE), U4.9 ((PCINT21/OC0B/T1)_PD5), U5.13 (!OE), U6.13 (!OE)
SFT-!RESET: U1.10 (!MR), U2.10 (!MR), U4.12 ((PCINT0/CLKO/ICP1)_PB0), U5.10 (!MR), U6.10 (!MR)
SFT-CLK: U1.11 (SHCP), U2.11 (SHCP), U4.11 ((PCINT23/AIN1)_PD7), U5.11 (SHCP), U6.11 (SHCP)
SFT-LATCH: U1.12 (STCP), U2.12 (STCP), U4.10 ((PCINT22/OC0A/AIN0)_PD6), U5.12 (STCP), U6.12 (STCP)

Board: 2 copper layers, 62.0 x 29.5 mm, 28 parts (2 on the bottom side), 57 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.6X

## EAGLE design 2017-2018/lcd-buzzer.brd

Board: 2 copper layers, 58.9 x 28.8 mm, 21 parts (1 on the bottom side), 54 nets.

Parts:
#1, #2, #3, #4: 74HC595PW; SOT403-1
C1: 47uF; EIA3528
C2: 1.0uF; 0603
C3: 0.1uF; 0603
C4, C5: 100nF; C0603
HAPTIC: DRV2605LDGSR; DGS10
K1: SKQGADE010; SW4-SMD-5.2X5.2X1.5MM
LCD: LCD-S401C39TR; S401C39TR
PS1240P02BT: PS1240P02BT
R1: 10k; 0603
R2: 10k; R0603
R3: 39k; R0603
SV1: MA03-2
TC33X-2-103E: TC33X; TC33X-2-103E
U1: ATMEGA328P-MUR; 32M1-A
U$1: MICRO-USB; GS-14-2180
U$3: ROBOBUZZ_0.6X

Connections:
1A: #1.1, LCD.P$35
1B: #1.2, LCD.P$34
1C: #1.3, LCD.P$7
1D: #1.4, LCD.P$6
1E: #1.5, LCD.P$5
1F: #1.6, LCD.P$36
1G: #1.7, LCD.P$37
2A: #2.1, LCD.P$30
2B: #2.2, LCD.P$29
2C: #2.3, LCD.P$11
2D: #2.4, LCD.P$10
2E: #2.5, LCD.P$9
2F: #2.6, LCD.P$31
2G: #2.7, LCD.P$32
3A: #3.1, LCD.P$25
3B: #3.2, LCD.P$24
3C: #3.3, LCD.P$15
3D: #3.4, LCD.P$14
3E: #3.5, LCD.P$13
3F: #3.6, LCD.P$26
3G: #3.7, LCD.P$27
4A: #4.1, LCD.P$21
4B: #4.2, LCD.P$20
4C: #4.3, LCD.P$19
4D: #4.4, LCD.P$18
4E: #4.5, LCD.P$17
4F: #4.6, LCD.P$22
4G: #4.7, LCD.P$23
!BTN: C4.1, C5.1, R3.2, U1.2
!RESET: R1.1, SV1.5, U1.29
+5V: #1.10, #1.16, #2.10, #2.16, #3.10, #3.16, #4.10, #4.16, C1.A, C3.1, HAPTIC.5, HAPTIC.10, R1.2, R2.2, SV1.2, TC33X-2-103E.CCW, U1.4, U1.6, U1.18, U$1.1
DIVIDED: LCD.P$1, LCD.P$40, TC33X-2-103E.WIPER
GND: #1.8, #1.13, #2.8, #2.13, #3.8, #3.13, #4.8, #4.13, C1.C, C2.1, C3.2, C4.2, C5.2, HAPTIC.4, HAPTIC.8, K1.2, K1.3, R2.1, SV1.6, TC33X-2-103E.CW, U1.3, U1.5, U1.21, U$1.5, U$1.5@1, U$1.5@2, U$1.5@3, U$1.5@4, U$1.5@6, U$1.5@7
LRA/ERM+: HAPTIC.7, PS1240P02BT.P$1
LRA/ERM-: HAPTIC.9, PS1240P02BT.P$2
MISO: SV1.1, U1.16
MOSI: SV1.4, U1.15
unnamed: K1.1, R3.1
unnamed: C2.2, HAPTIC.1
SCK: SV1.3, U1.17
SCL: HAPTIC.2, U1.28
SDA: HAPTIC.3, U1.27
SFT1: #1.14, U1.10
SFT2: #2.14, U1.7
SFT3: #3.14, U1.25
SFT4: #4.14, U1.1
SHIFT_CLK1: #1.12, U1.11
SHIFT_CLK2: #2.12, U1.8
SHIFT_CLK3: #3.12, U1.30
SHIFT_CLK4: #4.12, U1.32
STORAGE_CLK1: #1.11, U1.12
STORAGE_CLK2: #2.11, U1.9
STORAGE_CLK3: #3.11, U1.26
STORAGE_CLK4: #4.11, U1.31

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
COPYRIGHT: Copyright (C) 2022 Ultra Librarian. All rights reserved.
