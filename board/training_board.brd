# Repository RoboJackets/electrical-training (continued)

## EAGLE design training-pcb/rgb-led_alt.brd

Parts:
C1: 47uF; C1206
C2, C3, C4, C5, C6, C7: 0.1uF; C0603
D1: LED-RGB-CA-THRUCLEAR; LED-RGB-THRU
J1: MICRO-USB; GS-14-2180
J2: AVR_SPI_PROG2PTH2; 2X5-SHROUDED
LED1: WS2812B; 5050
R1: 220; R0603
R2, R4, R8, R9: 10k; R0603
R5, R6, R7: R-US_R0603; R0603
S1: SKQGADE010; SW4-SMD-5.2X5.2X1.5MM
U1: ATTINY441/841SSU/SSUR; SOIC-14
U2: PCA9533; SOIC8

Connections:
!BTN: C6.1, R2.1, S1.1 (A0), U1.11 (PA2(PCINT2/ADC2/AIN01/TOCC1/RXD0/SS'))
!RESET: J2.5 (RESET), R4.1, U1.4 (PB3(PCINT11/ADC9/RESET'/DW))
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C7.1, D1.2 (ANODE), J1.1, J2.2 (VCC), LED1.1 (VDD), R2.2, R4.2, R8.2, R9.2, U1.1 (VCC), U2.8 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.5, J1.5@1 (5), J1.5@2 (5), J1.5@3 (5), J1.5@4 (5), J1.5@6 (5), J1.5@7 (5), J2.4 (GND), J2.6 (GND), J2.8 (GND), J2.10 (GND), LED1.3 (VSS), S1.3 (B1), U1.14 (GND), U2.4 (VSS)
LED_CNTRL: R1.2, U1.10 (PA3(PCINT3/ADC3/AIN10/TOCC2/T0/XCK0/SCK))
MISO: J2.9 (MISO), U1.8 (PA5(PCINT5/ADC5/ACO0/TOCC4/T2/TXD1/MISO))
MOSI: J2.1 (MOSI), U1.7 (PA6(PCINT6/ADC6/ACO1/TOCC5/XCK1/SDA/MOS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)
unnamed: LED1.4 (DIN), R1.1
unnamed: D1.1 (RED_CATHODE), R5.2
unnamed: D1.3 (GREEN_CATHODE), R6.2
unnamed: D1.4 (BLUE_CATHODE), R7.2
unnamed: R5.1, U2.1 (LED0)
unnamed: R6.1, U2.2 (LED1)
unnamed: R7.1, U2.3 (LED2)
SCK: J2.7 (SCK), U1.9 (PA4(PCINT4/ADC4/AIN11/TOCC3/T1/RXD1/SCL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)
SCL: R9.1, U1.2 (PB0(PCINT8/ADC11/XTAL1/CLKI)), U2.6 (SCL)
SDA: R8.1, U1.3 (PB1(PCINT9/ADC10/XTAL2/INT0)), U2.7 (SDA)

Notes on the sheet:
Power
MCU
ICSP
LED

Board: 2 copper layers, 22 parts (0 on the bottom side), 17 nets, no tracks yet.

## Commit log (part)

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2016-08-19 Initial commit from past repository
2016-08-19 New voltage regulator, route board, condense libraries
2016-08-19 Fix routing error
2016-08-21 Switched RGB LED driver ICs, added button, NEEDS ROUTING
2016-08-21 made button inputs have RC circuit to debounce
2016-08-22 removed junk
2016-08-23 Fixed via overlap
2016-08-25 PCB fixes for overlaps
2016-08-25 Resize board to 30x30 then reroute
2016-08-25 Clean up routing, fix silkscreen labels
2016-08-26 Added pullup on reset pin
2016-08-26 Minor PCB changes, change resistor sizes
2016-08-26 Minor pcb routing changes
2016-08-26 Fix library files
2016-08-31 Adding Ignore List
2016-08-31 Eliminated Redundant Pull-Up Resistor
    The 10k on the +5V of the switch was redundant with the 39k series
    resistor already being present
    The 10k resistor has been removed
    The 39k was not value critical, so the value has been changed to 10k to
    reduce part count
2016-08-31 Removed the Series Resistor Instead
    Pull-Up was OK
    The 0.1uF capacitor should be sufficient to remove switch bounce
    All silkscreen has been moved to the top layer
2016-08-31 Optimized a Few Traces
2016-08-31 Silkscreen Optimization
2016-09-15 added markdown for upload to Attiny84
2016-09-16 Fixed RGB LED Footprint
2016-09-16 Got rid of a sharp corner
2016-09-16 Training board minor fixes for RGB led
2016-09-19 slides week 1
2016-09-27 added wk 2 slides
2016-10-03 files test commit
2016-10-03 This is a summary of my changes
    I dropped in a link to some sick beatz
2016-10-03 Revert "This is a summary of my changes"
    This reverts commit 2fc592a0f47edc7c51dc1ec486dabc59e25e973f.
2016-10-03 Added sweet new lines
    Its all about the interrupts
2016-10-04 Wk 3 slides
2016-10-17 Add Project Resources
2016-10-18 ya know, just working on the next big rap song
2016-10-20 Added scripts for training
2016-10-21 Updated script readme
2016-10-21 added wk 4 slides
2016-10-21 cheaters
2016-10-26 Pushing robocup edits
2016-10-31 Completed slides 5
2016-10-31 Slides 5 overview fix
2016-11-07 updated avrdude.conf
2016-11-07 attiny example
2016-11-16 added slides!
2017-07-31 First Version Completed
    Added extra custom parts to the library, completed the schematics
2017-08-01 Separate clocks for registers
2017-08-04 Minor Changes based on Manipulation w/ LCD
2017-08-13 Haptic Drive Update
2017-08-13 Board File Initial Commit
    Library Updated. 328p pin configuration reassigned
2017-08-16 added three buttons
2017-08-16 add image
2017-08-16 begin 3 button board
2017-08-23 3 Button Board completed
    LCD flipped, slight changes in shifter, Buzzer and SPI location
2017-08-24 Minor Updates
    Board rearranged to fit in MINI USB port. MINI USB port used as plenty
    of supply exists in the shop
2017-09-02 Board Updated according to Design Review
2017-09-07 Board Revision
    Reference Designator updated, wonky silkscreen fixed, Library updated
    and 2x3 header replaced with shrouded version
2017-09-08 Keep updating
    Changed to Class5, schematics alignment corrected.
2017-09-08 Some final glitches
2017-10-03 training board ver 1.5
2017-10-08 2nd Version
    Indicator LED added, ATMega328p package updated, schematics updated.
2017-10-08 LCD Column pin grounded
2017-10-11 Training Board Updated
    A list of changes:
    1. LCD COM pin: Now connected to Arduino Pin 13
    2. ^that also means the trimmer resistor is removed
    3. LED added, connected to Arduino Pin 12, can be the first thing for trainees to play with
    4. LCD_Reset connected to A3
    5. One of the three buttons is now a RESETN Button
2017-10-13 training board v1.1
2017-10-13 Button Connected
2017-10-28 added first draft of electrical programming slides
2017-10-29 made changes request in PR
2017-10-31 added button, led, and pwm examples
2017-11-01 a tad of cleanup and gitignore update
2017-11-02 a few lib updates
2017-11-02 some fixes to lcd lib
2017-11-02 a tad of cleanup
2017-11-02 small header update
2017-11-02 continuing with small fixes
2017-11-02 it works
2017-11-02 a bit of repo cleanup
2017-11-02 started tutorial
2017-11-02 finishied setup tutorial
2017-11-02 finishied setup tutorial, small patch
2017-11-02 added blinky tutorial
2017-11-02 progress
2017-11-02 finished PWM part
2017-11-02 minor fix
2017-11-02 added challenge
2017-11-06 fixed image references
2017-11-13 Markdown test
2017-11-13 Minor Change for testing purposes
2017-11-13 Saving Progress
2017-11-13 Keep updating stuff
2017-11-13 That's how you break a line?
2017-11-13 Almost done
2017-11-13 Mid night review
2017-11-13 Reviewed md
2018-07-21 Started schematic for training board based on atmega328p
2018-07-29 <Relevant Commit Message>
2018-08-03 Completed Schematic
2018-08-05 Routed Electrical Training board
2018-08-09 Routed with larger trace widths and corrected pinouts
2018-08-09 Replaced Thru-Hole with SMD Button
2018-08-10 Moved components around to match structure of Huzzah/Trainii
2018-08-13 Cleaned up the repo
2018-08-17 Moved some labels
2018-08-19 Added eagle training
2018-08-20 Switched positions of things
2018-08-21 Eagle Guide edited, adapted to Eagle 9 ver, added example of good vs bad routing
2018-08-21 Migrate all worksheets to LaTeX
2018-08-26 Added filtering caps and re-spec of LDO
2018-08-28 Add datasheets for eagle session
2018-09-01 Week 3 Worksheet ver 0.1
2018-09-06 Added Aesthetics and extra smoothing capacitors
2018-09-11 Additional updates to week 0 sheets
2018-09-12 Finalized the answer sheet
2018-09-12 Restructured Directory
2018-09-12 Added zip of week 0 worksheet
2018-09-23 Cleaned up name
2018-09-23 Cleaned up week 0 content
2018-09-23 Added Pdf to eagle guide
2018-09-23 Corrected the datasheets
2018-09-24 Added a zip of the week 0 pdfs
2018-09-29 Added week 2 training materials to master
2018-09-29 Added Week 1 slides
2018-09-30 Board Changes
    Made the name space bigger, remove thermal traces, rev board, round corner, move to origin
2018-09-30 Additional proof-reading for Week 3
2018-10-01 edited graphics and finished lab guide in LaTeX
2018-10-02 Fixed issue shorting power and ground on stop method lab 1
2018-10-03 Edited Pinouts
2018-10-03 Updated packages of LDO and improved usability
2018-10-03 Small DRC corrections and new gerbers
2018-10-07 Added week 2 slides
2018-10-11 Adds bootloader section to week 3 worksheet
2018-10-11 Deleting extra folders
2018-10-11 Fix minor error
2018-10-11 Created limited library as starting point for eagle CAD
2018-10-18 Readme file deleted
2018-10-22 Added Week 3 slides
2018-10-22 Added Fritzing files for week 3 worksheet example circuit
2018-10-29 Added week 4 slides
2018-11-12 Added week 6 slides
2019-08-01 Cleared out old training board
2019-08-02 Changed folder structure
2019-08-07 Added eagle-libraries as submodule and created blank files for schematic and board
2019-08-12 Preliminary Schematic completed. Components arranged and not routed on board.
2019-09-17 Added Week 0 content to references folder
2019-09-21 Updated Routing, added decoupling capacitors, and added silkscreen
2019-09-22 Added week0 contents and updated README
2019-09-23 Added Week 0 and 1 slides
2019-09-24 Added lab 1 document in references folder
2019-09-28 Removed duplicate and added most important change
2019-10-01 Added Week 2 lab document
2019-10-01 Updated Lab 1 Doc
2019-10-07 Added Week 3 Lab and Presentation
2019-10-09 Edited Lab 3 to reflect usage of buttons instead of switches
2019-10-20 eagle cheat sheet
2019-10-23 edited Week 4 slides after Tuesday
2019-10-27 Fixed Stylistic issues and parts associations
2019-11-12 Added manufacturing files and Component list
2019-11-13 Fixed typo in BOM
2019-11-19 Added datasheet for motor driver chip
2019-11-19 Added Lab 8 Document
2020-01-08 Added Week 5 Slides
2020-03-30 Added Tex Files for eagle cheat sheet
2020-04-01 Changed pdf to reflect tex changes
2020-04-01 Renamed eagle cheat sheet files, edited gitignore to ignore LaTeX intermediate files, and removed extraneous copy of eagle cheat sheet
2020-05-09 Removed 1 motor driver chip from training board
2020-05-09 Fixed reset issue and adjusted traces:
2020-05-10 Finished 1.3 rev silkscreen and layer fixes
2020-05-10 Updated to reference head on eagle libraries
2020-05-10 Removed eagle libraries submodule
2020-05-19 integrated DRV8871 into schematic and board
2020-05-20 Library updates, slight routing changes
2020-05-20 Adjusted board to fix silkscreen overlapping pads
2020-05-28 Fixed extra via and wire stub
2020-06-06 First draft of training board schematic, re-organized for two training board
2020-06-06 First draft of board
2020-06-06 Board aesthetic changes
2020-06-14 Fixed Resistor array part and changed orientation of LEDs.
2020-06-29 Create LICENSE
2020-06-29 Update LICENSE
2020-07-05 Removed unnecessary resistors, cleaned up routing
2020-07-05 Fixed angled routing
2020-07-06 added folder structure for electrical training labs
2020-07-07 Added week3 lab schematic
2020-07-07 Updated week3 lab schematic
2020-07-12 Deleted .BRD file
2020-07-17 Finished schematic, started board
2020-07-18 initial lbr commit
2020-07-19 First finished version
2020-07-19 Added curves to firmware board
2020-07-23 Moved parts to top
2020-07-23 Cleaned up silk screen
2020-07-28 Changed tag size, edited descriptions in schematic
2020-07-28 Fixed minor schematic notes, board silkscreen, and trace widths
2020-08-03 fixed right angle trace
2020-08-04 Moved 2 vias to avoid DRC
2020-08-04 Fixed silkscreen alignment
2020-09-17 week 0 content
2020-09-20 week 1 content
2020-09-27 week 2 content
2020-10-04 week 3 content
2020-10-04 added dues slide
2020-10-04 Added miscellaneous section with eagle tips to eagle cheat sheet
2020-10-04 Added author names and changed date
2020-10-08 removed button function step
2020-10-11 slides and template
2020-10-11 lab 4
2020-10-19 Clean up and week 5
2020-11-19 last minute board fixes
2020-11-19 Fixed wrong layer text
2020-11-19 Renamed SW2 to SW1
2020-11-19 Fixed minor issues and made roboBuzz bigger
2020-11-19 Fixed version
2021-09-20 Updated for 2021-2022 training
    Deleted all presentation and lab files from 2020-2021 training and added Week 0 slides for 2021-2022 training.
2021-09-27 Update README
    Changed 2020-2021
2021-09-28 Updated Lab 1
2021-10-03 Added Week 2 content
2021-10-04 Create Week2
2021-10-04 Updated links
2021-10-14 Adjusted
2021-10-18 Added Week 3 Material
2021-10-18 Added Week3 Schematic
2021-10-25 Added week 4 material
2021-11-15 Added lab and presentation for soldering/debugging training
2021-11-15 Fixed stuff
2021-11-17 Added firmware with error, edited slides
2022-08-28 Changed DRV8871 for DRV8876
2022-08-29 Added BOM
2022-08-29 Updated BOM
2022-08-30 Silkscreen edits
2022-09-16 Update slides for 2022-2023
    fun times
2023-09-18 Update year in presentation title and update week 0 slides
2023-09-18 Update README.md to 2022 for last year's training
2023-09-21 Upload final version of Week 0 presentation and delete outdated slides for later weeks
2023-09-21 Modify README to include more information about this repository and electrical training overall
2023-09-21 Update Kahoot QR code
2023-09-23 added new install instructions
2023-09-25 added new lab
2023-09-25 fixed typos
2023-09-28 Add Week 1 slides
2023-09-29 Reorganize LaTeX files
2023-09-29 Update electrical components and circuits reference with Varun's old edits
2023-10-02 Add Week 2 Lab and rename Week 1 Lab
2023-10-05 Add week 2 slides
2023-10-11 Add schematic for week 3 lab
2023-10-11 Add KiCad symbol library
2023-10-11 Update week 3 lab and add library for challenge
2023-10-12 Finalize changes for week 3 and add latex for week 2 and week 3
2023-10-16 Add lab files for Week 4
2023-10-16 Add KiCAD libraries for week 4
2023-10-17 Add LaTeX for week 4 lab
2023-10-17 Update week 4 lab to include explanation of pcb layers in KiCAD
2023-10-18 Quick fix for broken symbol library
2023-10-18 Fix schematic with fixed symbol
2023-10-25 Convert soldering training board from EAGLE to KiCad
2024-08-13 ommit message for your changes. Lines starting
2024-08-13 sleepy
2024-08-13 chimu tomodachi
2024-08-14 adding cheat files
2024-08-23 added labs 2,3,4
2024-09-02 updated week 0 meeting times
2024-09-03 proofread presentations and labs
