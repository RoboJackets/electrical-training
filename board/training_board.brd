File: board/training_board.brd (EAGLE design)
At the start: 68.6 x 53.4 mm, 24 parts, among them J1 MAIN_PWR, Q1 ARDUINOR3-NOIOREF-NOTEXT, Q2 DMN2056U, SW2 PTS645, U1 DRV8871HSOP-8

Commit message: Fixed extra via and wire stub
Routing:
- net RESET: track 23.2 -> 22.3 mm
- net GND: vias 18 -> 17
